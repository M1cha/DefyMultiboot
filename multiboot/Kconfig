## multiboot/Kconfig
```kconfig
config DEFY_MULTIBOOT
        tristate "Defy: Fix dmesg warnings in clocks like 1.3GHz"
        default m
        depends on SYMSEARCH
```
